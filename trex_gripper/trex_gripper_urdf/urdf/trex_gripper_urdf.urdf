Commit message: work_28_09_2021

File: trex_gripper/trex_gripper_urdf/urdf/trex_gripper_urdf.urdf (robot description, URDF)
Before this commit: robot trex_gripper_urdf, 7 links, 6 joints
Joints:
- joint virtual_joint: origin xyz=0 0 0.1 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0
